# Keil uVision project debug.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: debug
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: .\STM32F0-Discovery;.\STM32F0xx_StdPeriph_Driver\inc;.\CMSIS\Include;.\CMSIS\ST\STM32F0xx\Include;.\Arduino\inc;.\Arduino\Common;.\
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./: main.c Retarget.c
  group STM32F0-Discovery
    ./STM32F0-Discovery/: stm32f0_discovery.c
  group STM32F0xx_StdPeriph
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group MDK-ARM
    ./: system_stm32f0xx.c RTX_Conf_CM.c
    ./CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group Arduino
    ./Arduino/Common/: utilities.c
    ./Arduino/src/: gpio.c serial.c spi.c
